options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: OOT_HDL_module_creator_0
  id: OOT_HDL_module_creator
  parameters:
    file_path: /Users/salsamon/Documents/Magisterka/multiplier.v
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: int
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: multiplier_32b_0
  id: multiplier_32b
  parameters:
    dupa: '0'
    dupa2: '0'
    dupa3: '0'
  states: {}

connections:
- [analog_const_source_x_0, '0', multiplier_32b_0, '0']
- [multiplier_32b_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
